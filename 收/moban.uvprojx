# Keil uVision project moban.uvprojx, settings and files
target moban (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: moban +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\libraries\inc;.\libraries\src;.\startup;.\user;.\system\sys;.\system\delay;.\system\usart1;.\system\malloc;.\system\wdg;.\system\led;.\system\key;.\system\exti;.\system\adc;.\system\iic;.\app\at24cxx;.\system\spi1;.\system\spi2;.\app\NRF24L01
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c
  group system
    ./system/sys/: sys.c
    ./system/delay/: delay.c
    ./system/usart1/: usart1.c
    ./system/spi1/: spi1.c
    ./system/spi2/: spi2.c
  group app
    ./app/NRF24L01/: nrf24l01.c
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group libraries
    ./libraries/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_wwdg.c misc.c stm32f10x_dbgmcu.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_spi.c
software components: CMSIS:CORE 5.3.0
